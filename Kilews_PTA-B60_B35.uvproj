# Keil uVision project Kilews_PTA-B60_B35.uvproj, settings and files
target PTA-B60_B35 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: HP_PTA-B60_B35_M0516_38ba +hex
  BeforeMake: del_bin_hex.bat
  AfterMake: fromelf --bin ".\Output\@L.axf" --output ".\Output\@L.bin"
  AfterMake: CalCheckSum.bat
  c flags: OneElfS=1 wLevel=2
  c define: POLES2_SLOTS6,ScrewType=_PTA_X60,IDByPass=FALSE,ClutchBrakeWithBuzzer=TRUE
  c include: .\Include
  library: MicroLIB
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./CMSIS/: system_M051Series.c startup_M051Series.s
  group Library
    ./Library/: retarget.c gpio.c clk.c sys.c uart.c pwm.c adc.c i2c.c fmc.c wdt.c
  group User
    ./Source/: PtsPta_ADC.c PtsPta_FMC.c PtsPta_Init.c PtsPta_InputOutput.c PtsPta_ISR.c PtsPta_main.c PtsPta_Motor.c PtsPta_NVRAM.c PtsPta_Protection.c pid.c
target PTA-B60_B35_Debug (ARM-ADS)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: HP_PTA-B60_B35_ScottDebug_svnxxx +hex
  BeforeMake: del_bin_hex.bat
  AfterMake: fromelf --bin ".\Output\@L.axf" --output ".\Output\@L.bin"
  AfterMake: CalCheckSum.bat
  c flags: OneElfS=1 wLevel=2
  c define: POLES2_SLOTS6,ScrewType=_PTA_B60,IDByPass=FALSE,ClutchBrakeWithBuzzer=TRUE,Scott_Debug
  c include: .\Include
  library: MicroLIB
  link misc: as above
